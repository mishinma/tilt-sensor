# Keil uVision project tilt_sensor.uvprojx, settings and files
target STM32 (ARM-ADS)
  device: STM32F100C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tilt_sensor
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ./main;./CMSIS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group main
    ./main/: tilt_sensor.c i2c_driver.c lcd_driver.c
  group CMSIS
    ./CMSIS/: system_stm32f10x.c startup_stm32f10x_md_vl.s core_cm3.c
